options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: doppler_test_doppler_source_0
  id: doppler_test_doppler_source
  parameters:
    f_end: '20000'
    f_start: '5000'
    samp_rate: samp_rate
    sweep_time: '60.0'
  states: {}
- name: import0
  id: import
  parameters:
    imports: from gnuradio import doppler_test
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [doppler_test_doppler_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
